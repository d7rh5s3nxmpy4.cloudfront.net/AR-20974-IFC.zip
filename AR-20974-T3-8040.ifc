Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2026-02-24T10:26:50
Written by: Processor version 6.0.0.0
Made in: Xbim.IO.MemoryModel

# IfcDistributionPort (2)
Name | FlowDirection
 | SOURCE
 | SINK

# IfcFlowTerminal: AR-20974-T3-W40
Type - Description: Default Lamp Description; PredefinedType: FLUORESCENT
Photometric Information - Lamp names: AR-20974-T3-W40; Light output ratio: 1; Luminous flux: 3561.93 lm
Pset_LampTypeCommon - ContributedLuminousFlux: 3561.93 lm; LightEmitterNominalPower: 35.2 W; Spectrum: 380: 12934, 385: 1155, 390: 11614, 395: 10494, 400: 10484, 405: 10279, 410: 968, 415: 11352, 420: 17493, 425: 49381, 430: 110001, 435: 213323, 440: 422394, 445: 673726, 450: 939462, 455: 97829, 460: 851938, 465: 670014, 470: 609521, 475: 402322, 480: 38367, 485: 36832, 490: 382506, 495: 423255, 500: 468951, 505: 504823, 510: 541923, 515: 57673, 520: 57894, 525: 611155, 530: 613829, 535: 629598, 540: 636475, 545: 644361, 550: 654589, 555: 661682, 560: 680295, 565: 709359, 570: 720587, 575: 748998, 580: 767832, 585: 786295, 590: 801043, 595: 812518, 600: 8201303, 605: 827334, 610: 837494, 615: 829016, 616: 814072, 617: 810179, 618: 806287, 619: 803012, 620: 797737, 625: 764787, 630: 754964, 635: 680899, 640: 658133, 645: 604845, 650: 585125, 655: 55894, 660: 486181, 665: 454614, 670: 432297, 675: 388355, 680: 352992, 685: 328193, 690: 282697, 695: 245701, 700: 235906, 705: 199853, 710: 163229, 715: 14476, 720: 13737, 725: 124158, 730: 97674, 735: 85444, 740: 75708, 745: 68751, 750: 61453, 755: 56451, 760: 52251; ColorTemperature: 4000 K; ColorRenderingIndex: 80

# IfcFlowTerminal: ARIZONA 2 Light columns
In: Default Building
Type - Description: · Lamp LED · CRI Ra > 80 · MacAdam Ellipse 3 SDCM · Colour 3000K and 4000K - Die-cast aluminium housing and extruded aluminium column pre-treated before powder coating ensuring high corrosion resistance - Stainless steel fasteners in grade 316 - Durable silicone rubber gasket - High-efficiency optical reflector or PMMA lens - Clear, acrylic PMMA diffuser - Maximum wind load resistance is 140 km/h - Surge protection 10kV; PredefinedType: DIRECTIONSOURCE
Type - Pset_ManufacturerTypeInformation - ArticleNumber: AR-20974-T3-8040; ModelReference: ARIZONA 2 Light columns; Manufacturer: LIGMAN
Type - Pset_LightFixtureTypeCommon - NumberOfSources: 1; TotalWattage: 35.2 W; LightFixtureMountingType: Standing; LightFixturePlacingType: Floor; ManufacturersSpecificInformation: LIGMAN
Material: layer 10 mm
Marketing Information - Emergency lighting possible: no; Product group: ARIZONA, Light columns; Housing color: White, Black, Silver
General Information - Weight: 34.8 kg; Case height: 367.6 cm; Case diameter: 22.5 cm; Uld creation date: 24.02.2026 09:26:50
Pset_ElectricalDeviceCommon - ElectricalDeviceNominalPower: 35.2 W
